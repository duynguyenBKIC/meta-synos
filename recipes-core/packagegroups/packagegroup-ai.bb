# Copyright (c) 2026 SynOS Developers.

SUMMARY = "SynOS AI packages"
DESCRIPTION = "Define groups of packages that provide AI framework"

inherit packagegroup

RDEPENDS:${PN} = ""

